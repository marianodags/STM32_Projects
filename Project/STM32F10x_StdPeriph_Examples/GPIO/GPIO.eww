<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/IOToggle/IOToggle.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$/JTAG_Remap/JTAG_Remap.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>IOToggle</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>IOToggle</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>IOToggle</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>IOToggle</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>IOToggle</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>IOToggle</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
      <member>
        <project>JTAG_Remap</project>
        <configuration>STM32100B-EVAL</configuration>
      </member>
      <member>
        <project>JTAG_Remap</project>
        <configuration>STM32100E-EVAL</configuration>
      </member>
      <member>
        <project>JTAG_Remap</project>
        <configuration>STM3210B-EVAL</configuration>
      </member>
      <member>
        <project>JTAG_Remap</project>
        <configuration>STM3210C-EVAL</configuration>
      </member>
      <member>
        <project>JTAG_Remap</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>JTAG_Remap</project>
        <configuration>STM3210E-EVAL_XL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
