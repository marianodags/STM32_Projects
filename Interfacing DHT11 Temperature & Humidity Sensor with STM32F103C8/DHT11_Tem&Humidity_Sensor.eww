<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\DHT11_Tem&amp;Humidity_Sensor.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\stm32gpio\arm\9.30.1\ST\STM32F1xx\stm32f10x_stdperiph_lib\Project\STM32F10x_StdPeriph_Examples\GPIO\IOToggle\IOToggle.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\stm32gpio\arm\9.30.1\ST\STM32F1xx\stm32f10x_stdperiph_lib\Project\STM32F10x_StdPeriph_Examples\GPIO\JTAG_Remap\JTAG_Remap.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>All</name>
            <member>
                <project>IOToggle</project>
                <configuration>STM32100B-EVAL</configuration>
            </member>
            <member>
                <project>IOToggle</project>
                <configuration>STM32100E-EVAL</configuration>
            </member>
            <member>
                <project>IOToggle</project>
                <configuration>STM3210B-EVAL</configuration>
            </member>
            <member>
                <project>IOToggle</project>
                <configuration>STM3210C-EVAL</configuration>
            </member>
            <member>
                <project>IOToggle</project>
                <configuration>STM3210E-EVAL</configuration>
            </member>
            <member>
                <project>IOToggle</project>
                <configuration>STM3210E-EVAL_XL</configuration>
            </member>
            <member>
                <project>JTAG_Remap</project>
                <configuration>STM32100B-EVAL</configuration>
            </member>
            <member>
                <project>JTAG_Remap</project>
                <configuration>STM32100E-EVAL</configuration>
            </member>
            <member>
                <project>JTAG_Remap</project>
                <configuration>STM3210B-EVAL</configuration>
            </member>
            <member>
                <project>JTAG_Remap</project>
                <configuration>STM3210C-EVAL</configuration>
            </member>
            <member>
                <project>JTAG_Remap</project>
                <configuration>STM3210E-EVAL</configuration>
            </member>
            <member>
                <project>JTAG_Remap</project>
                <configuration>STM3210E-EVAL_XL</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
