# IAR project PWM_LED.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C6 ST STM32F103C6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103x6; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ; ..\..\Flash_LED_using_PWM\STM32F1xx_HAL_Driver\Src; ..\..\Flash_LED_using_PWM\STM32F1xx_HAL_Driver\Inc; ..\..\Flash_LED_using_PWM\CMSIS\Device\ST\STM32F1xx\Include; ..\..\Flash_LED_using_PWM\CMSIS\CM3\CoreSupport
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c main.h
  group Board
    ./: stm32f1xx_bluepill.h
  group CMSIS
    ./: stm32f1xx_hal_conf.h stm32f1xx_it.c stm32f1xx_it.h system_stm32f1xx.c
  group Startup
    ./: startup_stm32f103xb.s
  group STM32_Lib
    ./: i2c-lcd.c i2c-lcd.h
    ../STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_gpio.c stm32f1xx_hal_i2c.c stm32f1xx_hal_msp.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
    ../STM32F1xx_HAL_Driver/Inc/: stm32f1xx_hal.h stm32f1xx_hal_cortex.h stm32f1xx_hal_dma.h stm32f1xx_hal_flash.h stm32f1xx_hal_gpio.h stm32f1xx_hal_i2c.h stm32f1xx_hal_pwr.h stm32f1xx_hal_rcc.h stm32f1xx_hal_tim.h stm32f1xx_hal_tim_ex.h stm32f1xx_hal_uart.h
